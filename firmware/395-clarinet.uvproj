# Keil uVision project 395-clarinet.uvproj, settings and files
target 395-clarinet (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1114/202 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: serial
  c flags: Optim=1 uC99=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Startup
    ./LPC11xx/: system_LPC11xx.c startup_LPC11xx.s
  group Serial
    ./: Serial.c Retarget.c
  group firmware
    ./LPC11xx/: LPC11xx.h core_cm0.h core_cmFunc.h core_cmInstr.h system_LPC11xx.c system_LPC11xx.h
    ./: main.c header.h
    ./BMP180/: BMP180.c BMP180.h
    ./delay/: delay.c delay.h
    ./gpio/: gpio.c gpio.h
    ./i2c/: i2c.c i2c.h
    ./midi/: midi.c midi.h
    ./note/: note.c note.h
    ./pid/: pid.c pid.h
    ./pressure/: pressure.c pressure.h
    ./pwm/: pwm.c pwm.h
    ./servo/: servo.c servo.h
    ./spi/: spi.c spi.h
    ./system/: system.c system.h
    ./uart/: uart.c uart.h
