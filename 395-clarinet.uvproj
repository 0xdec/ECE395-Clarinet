# Keil uVision project 395-clarinet.uvproj, settings and files
target 395-clarinet (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1114/202 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: serial
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Startup
    ./: startup_LPC11xx.s system_LPC11xx.c
  group Serial
    ./: Serial.c Retarget.c
  group firmware
    ./: main.c
    ./firmware/: delay.c gpio.c midi.c notes.c pwm.c servo.c system.c uart.c delay.h gpio.h header.h midi.h notes.h pwm.h servo.h system.h uart.h
